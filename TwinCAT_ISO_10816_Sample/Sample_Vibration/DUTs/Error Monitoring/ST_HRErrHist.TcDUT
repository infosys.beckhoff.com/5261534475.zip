TYPE ST_HRErrHist :
STRUCT
{attribute 'displaymode':='hex'}
	hrErrCode	: HRESULT;
	sErrSource	: STRING(63);
	nErrCount	: UDINT;
END_STRUCT
END_TYPE
