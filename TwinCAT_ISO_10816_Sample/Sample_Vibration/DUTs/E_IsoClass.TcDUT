(* ISO Classes *)
{attribute 'qualified_only'}
TYPE E_IsoClass :
(
	N := 0,	// No valid result
	A,		// OK
	B,		// Info
	C,		// Warning
	D		// Failure
) UDINT;
END_TYPE
