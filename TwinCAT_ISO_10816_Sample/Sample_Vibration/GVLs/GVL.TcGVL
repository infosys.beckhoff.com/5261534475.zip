VAR_GLOBAL
	(* error monitoring *)
	fbErrHist	: FB_HRErrHist;
END_VAR
